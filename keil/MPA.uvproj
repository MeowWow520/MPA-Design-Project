# Keil uVision project MPA.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MPA +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ../src/: LCD.h Keypad.h Game.h Delay.h def.h main.c LCD.c Keypad.c Game.c Delay.c
